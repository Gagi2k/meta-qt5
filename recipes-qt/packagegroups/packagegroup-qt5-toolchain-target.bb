DESCRIPTION = "Target packages for Qt SDK"

require packagegroup-qt5-toolchain-target.inc

RDEPENDS_${PN} += " \
        "
