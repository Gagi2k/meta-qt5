require nativesdk-packagegroup-qt5-toolchain-host.inc

DESCRIPTION = "Host packages for Qt SDK"
