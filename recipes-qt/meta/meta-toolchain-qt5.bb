# Qt toolchain
QTNAME = "qt5"
QT_DIR_NAME = "qt5"

require meta-toolchain-qt5.inc
